# Keil uVision project supreme-almond.uvproj, settings and files
target Target 1 (MCS-51)
  device: C517A-L Infineon
  cpu: IRAM(0-0xFF) CLOCK(24000000) MOD517DP MOD517AU XRAM(0xF800-0xFFFF)
  output: supreme-almond
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    $TC_ROOT$/../../supreme-almond/: code.a51
